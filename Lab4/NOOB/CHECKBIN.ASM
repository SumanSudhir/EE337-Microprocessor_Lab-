ORG 0000H
ljmp MAIN
org 200H

BIN2ASCII:
		PUSH 60H
		PUSH 61H
		;PUSH AR0
		
		MOV R0,#30H
		
		MOV 60H,A
		ANL A,#0FH
		SUBB A,#10
		MOV A,60H
		ANL A,#0FH
		JNC SKIP
		LCALL LOOP2
		SJMP SKIP2
SKIP:
		ANL A,#0FH
		LCALL LOOP1
		
SKIP2:
		MOV A,60H
		ANL A,#0F0H
		SWAP A
		MOV 61H,A
		CLR C
		SUBB A,#10
		MOV A,61H
		JNC SKIP3
		LCALL LOOP2
		
		;POP AR0
		POP 61H
		POP 60H
RET	
SKIP3:LCALL LOOP1
LOOP1: 
		ADD A,#37H
		MOV @R0,A
		INC R0
		CLR C
RET
	
LOOP2:
		ADD A,#30H
		MOV @R0,A
		INC R0
RET
		
;RET	
MAIN:
MOV A,#0FH

LCALL BIN2ASCII
HERE:SJMP HERE

END